<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F411CE_MAX7219.ewp</path>
  </project>
  <batchBuild />
</workspace>
